# Keil uVision project MyProject.uvprojx, settings and files
target MSP432 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MyProject
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __MSP432P401R__
  c include: .\ti\grlib;.\third_party\CMSIS;.\ti\devices\msp432p4xx\inc;.\;.\LcdDriver;.\ti\devices\msp432p4xx\driverlib
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group MyPrograms
    ./: MyHeader.h graphics.h ass.c
  group Library
    ./ti/grlib/lib/keil/m4f/: grlib.a
    ./LcdDriver/: Crystalfontz128x128_ST7735.h HAL_MSP_EXP432P401R_Crystalfontz128x128_ST7735.h Crystalfontz128x128_ST7735.c HAL_MSP_EXP432P401R_Crystalfontz128x128_ST7735.c
    ./ti/devices/msp432p4xx/driverlib/keil/: msp432p4xx_driverlib.lib
software components: CMSIS:CORE 5.1.2, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 3.2.2
